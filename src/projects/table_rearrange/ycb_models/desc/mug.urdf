Commit message: Removed unused nodes, enhanced functionality

File: src/projects/table_rearrange/ycb_models/desc/mug.urdf (robot description, URDF)
Before this commit: robot mug, 2 links, 1 joints
Links:
- link mug: mass 0.1 -> 1
