Commit message: fixed torque discontinuity

File: ros_ws/src/projects/dexterous_in_hand_manip/object_description/urdf/long_block.urdf (robot description, URDF)
Before this commit: robot block_object, 1 links, 0 joints
Links:
- link block: mass 0.1 -> 0.072
